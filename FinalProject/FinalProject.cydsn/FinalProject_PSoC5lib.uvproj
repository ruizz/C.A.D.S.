# Keil uVision project FinalProject_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: FinalProject_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h AMux_1.c AMux_1.h Pin_1_aliases.h Pin_1.c Pin_1.h Pin_2_aliases.h Pin_2.c Pin_2.h Pin_3_aliases.h Pin_3.c Pin_3.h Pin_4_aliases.h Pin_4.c Pin_4.h ADC_SAR_1.c ADC_SAR_1.h ADC_SAR_1_INT.c ADC_SAR_1_PM.c LCD_Char_1.c LCD_Char_1.h LCD_Char_1_PM.c Pin_5_aliases.h Pin_5.c Pin_5.h VDAC8_1.c VDAC8_1.h VDAC8_1_PM.c ADC_SAR_1_IRQ.c ADC_SAR_1_IRQ.h ADC_SAR_1_theACLK.c ADC_SAR_1_theACLK.h ADC_SAR_1_Bypass_aliases.h ADC_SAR_1_Bypass.c ADC_SAR_1_Bypass.h LCD_Char_1_LCDPort_aliases.h LCD_Char_1_LCDPort.c LCD_Char_1_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Counter_1.c Counter_1.h Counter_1_PM.c Control_Reg_1.c Control_Reg_1.h Period_1MHz.c Period_1MHz.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: FinalProject_PSoC5lib (library)
